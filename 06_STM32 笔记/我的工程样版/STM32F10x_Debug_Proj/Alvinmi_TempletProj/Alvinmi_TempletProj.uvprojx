# Keil uVision project Alvinmi_TempletProj.uvprojx, settings and files
target Alvinmi_TempletProj (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Alvinmi_TempletProj +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\USER;.\STM32F10x_FWLib\inc;.\USER\sys;.\USER\delay;.\USER\usart;.\Function\epson_m150;.\USER\timer;.\Function\oled;.\Function\lcd;.\Function\soft_iic
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
    ./USER/sys/: sys.c
    ./USER/delay/: delay.c
    ./USER/timer/: timer.c
    ./USER/usart/: uart.c
  group Function
    ./Function/epson_m150/: epson_m150ii.c
    ./Function/oled/: oled.c
    ./Function/lcd/: lcd.c
    ./Function/soft_iic/: i2c_soft.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
